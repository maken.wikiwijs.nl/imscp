# Autodesk Inventor assembly: Steekwagen
## iProperties
Created: 2007-06
Part Number: Steekwagen
Document SubType Name: Assembly
Designer: Phil Trethewie
Author: Phil Trethewie
