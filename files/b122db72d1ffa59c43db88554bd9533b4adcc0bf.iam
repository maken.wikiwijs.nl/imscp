# Autodesk Inventor assembly: Steekwagen-1
## iProperties
Created: 2007-06
Part Number: Steekwagen-1
Document SubType Name: Assembly
Designer: Phil Trethewie
Author: Phil Trethewie
